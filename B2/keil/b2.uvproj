# Keil uVision project b2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: b2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 b2.c lcd.c delay.c key.c uart.c uart.h lcd.h delay.h key.h xor.c xor.h
